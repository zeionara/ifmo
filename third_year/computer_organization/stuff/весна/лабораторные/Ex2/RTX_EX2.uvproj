# Keil uVision project RTX_EX2.uvproj, settings and files
target RTX51 Tiny Ex2 (MCS-51)
  device: 80C51BH Intel
  cpu: IRAM(0-0x7F)  IROM(0-0xFFF) CLOCK(12000000)
  output: RTX_EX2
  c flags: Optimize=8 SizeSpeed=1
  group Source Files
    ./: RTX_EX2.C ABSTRACT.TXT Conf_tny.A51
